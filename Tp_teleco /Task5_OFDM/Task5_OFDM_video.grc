options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: ofdm_loopback_example
    max_nouts: '100000'
    output_language: python
    title: OFDM Loopback Example
  states: {}

blocks:
- name: cp_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: epsilon
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '.01'
    stop: '10'
    value: '0.0'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '188'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/task5_ofdm188_channel_rx.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /tmp/task5_pdu188_in_test.ts
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    maxoutbuf: '262144'
    minoutbuf: '65536'
    occupied_carriers: (tuple(list(range(-26,-21)) + list(range(-20,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,21)) + list(range(22,27))),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: ((1,1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: cp_len
    fft_len: fft_len
    header_mod: '"BPSK"'
    maxoutbuf: '262144'
    minoutbuf: '65536'
    occupied_carriers: (tuple(list(range(-26,-21)) + list(range(-20,-7)) + list(range(-6,0)) + list(range(1,7)) + list(range(8,21)) + list(range(22,27))),)
    packet_len_key: packet_len
    payload_mod: '"QPSK"'
    pilot_carriers: ((-21,-7,7,21),)
    pilot_symbols: ((1,1,1,-1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import pmt
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Divide cualquier PDU entrante en PDUs MPEG-TS de 188 bytes.
          Entrada: mensajes PDU desde Socket PDU.
          Salida: mensajes PDU de exactamente 188 bytes.
          """

          def __init__(self):
              gr.basic_block.__init__(
                  self,
                  name="pdu_ts_splitter_188",
                  in_sig=[],
                  out_sig=[]
              )

              self.packet_size = 188
              self.buffer = bytearray()

              self.message_port_register_in(pmt.intern("pdus"))
              self.message_port_register_out(pmt.intern("pdus"))
              self.set_msg_handler(pmt.intern("pdus"), self.handle_pdu)

          def handle_pdu(self, msg):
              if not pmt.is_pair(msg):
                  return

              meta = pmt.car(msg)
              vec = pmt.cdr(msg)

              if not pmt.is_u8vector(vec):
                  return

              data = bytes(pmt.u8vector_elements(vec))
              self.buffer.extend(data)

              ps = self.packet_size

              while len(self.buffer) >= ps:
                  # Buscar sincronismo MPEG-TS 0x47.
                  if self.buffer[0] != 0x47:
                      sync_pos = self.buffer.find(0x47)

                      if sync_pos < 0:
                          # No hay sincronismo; conservar pocos bytes por seguridad.
                          self.buffer = self.buffer[-ps:]
                          return

                      del self.buffer[:sync_pos]

                      if len(self.buffer) < ps:
                          return

                  packet = bytes(self.buffer[:ps])
                  del self.buffer[:ps]

                  out_vec = pmt.init_u8vector(ps, list(packet))
                  out_msg = pmt.cons(meta, out_vec)

                  self.message_port_pub(pmt.intern("pdus"), out_msg)
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: 0.0.0.0
    mtu: '2048'
    port: '4999'
    type: UDP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    host: 127.0.0.1
    mtu: '10000'
    port: '5000'
    type: UDP_CLIENT
  states: {state: disabled}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '188'
    port: '5000'
    send_eof: 'False'
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: fdm emisor
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Channel
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: ofdm emisor
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_rx_0, '0']
- [channels_channel_model_0, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', network_udp_sink_0, '0']
- [digital_ofdm_rx_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_ofdm_tx_0, '0', blocks_throttle_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_ofdm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, pdus, pdu_pdu_to_tagged_stream_0, pdus]
- [network_socket_pdu_0, pdus, epy_block_0, pdus]
- [pdu_pdu_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, network_socket_pdu_1, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
