options:
  parameters:
    author: popo
    generate_options: qt_gui
    id: task3_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: ppm
  id: variable
  parameters:
    value: '0'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: udp_out_port
  id: variable
  parameters:
    value: '5001'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.05'
    mu: '0.5'
    omega_relative_limit: '0.01'
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      from collections import deque

      class blk(gr.basic_block):
          """
          Buffer y resincronizador simple para paquetes MPEG-TS.

          Entrada:
              Stream de bytes desde Pack K Bits.

          Salida:
              Stream de bytes hacia UDP Sink.

          Función:
              - Busca paquetes MPEG-TS de 188 bytes.
              - Acepta solamente paquetes cuyo primer byte sea 0x47.
              - Acumula una cantidad mínima antes de entregar.
              - Introduce retardo, pero mejora la estabilidad de entrega.
          """

          def __init__(self, packet_len=188, preload_packets=30):
              gr.basic_block.__init__(
                  self,
                  name="ts_buffer_resync",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )

              self.packet_len = int(packet_len)
              self.preload_packets = int(preload_packets)

              self.rx_buffer = bytearray()
              self.packet_queue = deque()

              self.started = False

              self.rx_count = 0
              self.valid_count = 0
              self.drop_count = 0

              self.set_output_multiple(self.packet_len)

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              # Consumir todos los bytes disponibles de entrada
              if len(inp) > 0:
                  self.rx_buffer.extend(bytes(inp))
                  self.rx_count += len(inp)
                  self.consume(0, len(inp))

              # Buscar paquetes MPEG-TS alineados por 0x47
              while len(self.rx_buffer) >= self.packet_len:
                  # Si el primer byte es 0x47, tomamos el paquete completo
                  if self.rx_buffer[0] == 0x47:
                      pkt = bytes(self.rx_buffer[:self.packet_len])
                      del self.rx_buffer[:self.packet_len]

                      self.packet_queue.append(pkt)
                      self.valid_count += 1

                  else:
                      # Buscar el próximo posible sync byte 0x47
                      try:
                          idx = self.rx_buffer.index(0x47, 1)
                          del self.rx_buffer[:idx]
                          self.drop_count += idx
                      except ValueError:
                          # Si no hay 0x47, descartamos casi todo y dejamos cola mínima
                          keep = min(len(self.rx_buffer), self.packet_len - 1)
                          self.drop_count += len(self.rx_buffer) - keep
                          self.rx_buffer = self.rx_buffer[-keep:]
                          break

              # Esperar hasta tener un buffer inicial
              if not self.started:
                  if len(self.packet_queue) >= self.preload_packets:
                      self.started = True
                  else:
                      return 0

              # Entregar paquetes completos de 188 bytes
              max_packets_out = len(out) // self.packet_len
              packets_to_send = min(max_packets_out, len(self.packet_queue))

              if packets_to_send == 0:
                  self.started = False
                  return 0

              pos = 0
              for _ in range(packets_to_send):
                  pkt = self.packet_queue.popleft()
                  out[pos:pos + self.packet_len] = np.frombuffer(pkt, dtype=np.uint8)
                  pos += self.packet_len

              return pos
    packet_len: '188'
    preload_packets: '30'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Sincronizador MPEG-TS robusto por bits.

          Entrada:
              Bits uint8 desde GMSK Demod.

          Salida:
              Bytes uint8 alineados en paquetes MPEG-TS de 188 bytes.
          """

          def __init__(self,
                       packet_len=188,
                       sync_byte=0x47,
                       lock_window=9,
                       lock_threshold=8,
                       unlock_after=20,
                       max_buffer_bits=500000,
                       debug=True):

              gr.basic_block.__init__(
                  self,
                  name="mpegts_bit_sync_robust",
                  in_sig=[np.uint8],
                  out_sig=[np.uint8],
              )

              self.packet_len = int(packet_len)
              self.sync_byte = int(sync_byte) & 0xFF
              self.lock_window = int(lock_window)
              self.lock_threshold = int(lock_threshold)
              self.unlock_after = int(unlock_after)
              self.max_buffer_bits = int(max_buffer_bits)
              self.debug = bool(debug)

              self.packet_bits = self.packet_len * 8
              self.bits = []
              self.locked = False
              self.bad_packets = 0

              self.set_output_multiple(self.packet_len)

          def _byte_at(self, bit_pos):
              if bit_pos + 8 > len(self.bits):
                  return None

              value = 0

              for b in self.bits[bit_pos:bit_pos + 8]:
                  value = (value << 1) | (int(b) & 1)

              return value & 0xFF

          def _packet_to_bytes(self, start_bit):
              pkt = bytearray(self.packet_len)

              for i in range(self.packet_len):
                  b = self._byte_at(start_bit + i * 8)

                  if b is None:
                      return None

                  pkt[i] = b

              return bytes(pkt)

          def _find_sync(self):
              required_bits = (self.lock_window - 1) * self.packet_bits + 8

              if len(self.bits) < required_bits:
                  return False

              last_start = len(self.bits) - required_bits + 1

              for start in range(last_start):

                  if self._byte_at(start) != self.sync_byte:
                      continue

                  hits = 1

                  for k in range(1, self.lock_window):
                      pos = start + k * self.packet_bits

                      if self._byte_at(pos) == self.sync_byte:
                          hits += 1

                  if hits >= self.lock_threshold:

                      if start > 0:
                          del self.bits[:start]

                      self.locked = True
                      self.bad_packets = 0

                      if self.debug:
                          print(
                              f"[mpegts_bit_sync] LOCK start={start}, "
                              f"hits={hits}/{self.lock_window}"
                          )

                      return True

              if len(self.bits) > self.max_buffer_bits:
                  keep = required_bits + self.packet_bits
                  self.bits = self.bits[-keep:]

              return False

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              if len(inp) > 0:
                  self.bits.extend((inp & 1).astype(np.uint8).tolist())

              self.consume(0, len(inp))

              produced = 0

              if not self.locked:
                  self._find_sync()
                  return 0

              while len(self.bits) >= self.packet_bits and produced + self.packet_len <= len(out):

                  sync = self._byte_at(0)

                  if sync == self.sync_byte:
                      pkt = self._packet_to_bytes(0)

                      if pkt is None:
                          break

                      out[produced:produced + self.packet_len] = np.frombuffer(
                          pkt, dtype=np.uint8
                      )

                      produced += self.packet_len

                      del self.bits[:self.packet_bits]
                      self.bad_packets = 0

                  else:
                      # Antes de descartar un paquete completo, buscar si el 0x47
                      # está corrido algunos bits hacia adelante.
                      shift_found = None

                      for shift in range(1, 8):
                          if self._byte_at(shift) == self.sync_byte:
                              shift_found = shift
                              break

                      if shift_found is not None:
                          if self.debug:
                              print(
                                  f"[mpegts_bit_sync] BIT REALIGN shift={shift_found}, "
                                  f"old_sync=0x{sync:02X}"
                              )

                          del self.bits[:shift_found]
                          self.bad_packets = 0
                          continue

                      # Si no hay realineación local posible, recién ahí se descarta el paquete.
                      self.bad_packets += 1

                      if self.debug:
                          print(
                              f"[mpegts_bit_sync] BAD packet sync=0x{sync:02X}, "
                              f"bad={self.bad_packets}/{self.unlock_after}"
                          )

                      del self.bits[:self.packet_bits]

                      if self.bad_packets >= self.unlock_after:
                          if self.debug:
                              print("[mpegts_bit_sync] LOST LOCK")

                          self.locked = False
                          self.bad_packets = 0
                          self._find_sync()

                          if not self.locked:
                              break

              return produced
    debug: 'True'
    lock_threshold: '8'
    lock_window: '9'
    max_buffer_bits: '500000'
    packet_len: '188'
    sync_byte: '0x47'
    unlock_after: '20'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '186900'
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 300e3, 100e3)
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '188'
    port: udp_out_port
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    comment: |-
      El RTL entrega una señal compleja de bandabase. 
      Trae la señal alrededor de "Centrer freq" a BB


      la señal en por ejemplo 105.4FM se trae hasta la banda base
    freq_correction: ppm
    gain: rx_gain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', digital_gmsk_demod_0, '0']
- [digital_gmsk_demod_0, '0', epy_block_1, '0']
- [epy_block_0, '0', network_udp_sink_0, '0']
- [epy_block_1, '0', network_udp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_agc2_xx_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
