options:
  parameters:
    author: popo
    generate_options: qt_gui
    id: Task3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bt
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: tx_amp
  id: variable
  parameters:
    value: '0.20'
  states: {}
- name: tx_vga
  id: variable
  parameters:
    value: '20'
  states: {}
- name: udp_port
  id: variable
  parameters:
    value: '5000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '3'
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0x47] + [0x00]*187'
  states: {state: disabled}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: bt
    do_unpack: 'False'
    samples_per_symbol: sps
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import socket
      import time
      from collections import deque

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """
          Fuente MPEG-TS continua para GNU Radio.

          - Escucha paquetes MPEG-TS por UDP.
          - Reordena a paquetes de 188 bytes.
          - Si no hay video disponible, emite paquetes nulos MPEG-TS.
          - Evita que el modulador GMSK se quede sin datos.
          """

          def __init__(self, in_port=4999, packet_len=188,
                       max_queue_packets=500, debug=False):

              gr.sync_block.__init__(
                  self,
                  name="mpegts_udp_pacer_source",
                  in_sig=[],
                  out_sig=[np.uint8],
              )

              self.in_port = int(in_port)
              self.packet_len = int(packet_len)
              self.max_queue_packets = int(max_queue_packets)
              self.debug = bool(debug)

              # Generador pseudoaleatorio para el payload de paquetes nulos.
              self.lfsr = 0xACE1

              self.queue = deque()
              self.rxbuf = bytearray()

              self.sent_video = 0
              self.sent_null = 0
              self.dropped = 0
              self.last_print = time.monotonic()

              self.sock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
              self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_REUSEADDR, 1)

              try:
                  self.sock.setsockopt(socket.SOL_SOCKET, socket.SO_RCVBUF, 2 * 1024 * 1024)
              except Exception:
                  pass

              self.sock.bind(("127.0.0.1", self.in_port))
              self.sock.setblocking(False)

              self.set_output_multiple(self.packet_len)

              if self.debug:
                  print(f"[mpegts_udp_pacer_source] Escuchando UDP {self.in_port}")

          def _pn_byte(self):
              """
              Genera un byte pseudoaleatorio mediante LFSR de 16 bits.
              Se usa solamente para rellenar el payload de paquetes nulos MPEG-TS.
              """

              out = 0

              for _ in range(8):
                  newbit = (
                      ((self.lfsr >> 0) ^
                       (self.lfsr >> 2) ^
                       (self.lfsr >> 3) ^
                       (self.lfsr >> 5)) & 1
                  )

                  self.lfsr = ((self.lfsr >> 1) | (newbit << 15)) & 0xFFFF
                  out = (out << 1) | (self.lfsr & 1)

              return out & 0xFF

          def _make_null_packet(self):
              """
              Genera un paquete nulo MPEG-TS válido.

              Header:
                  0x47       sync byte
                  0x1F 0xFF  PID = 0x1FFF, paquete nulo
                  0x10       payload only
              """

              payload = bytes(self._pn_byte() for _ in range(self.packet_len - 4))
              return bytes([0x47, 0x1F, 0xFF, 0x10]) + payload

          def _drain_udp(self):
              """
              Lee todos los datagramas UDP disponibles sin bloquear.
              Extrae paquetes MPEG-TS de 188 bytes alineados con 0x47.
              """

              for _ in range(100):
                  try:
                      data, _addr = self.sock.recvfrom(65536)
                  except BlockingIOError:
                      break

                  if not data:
                      break

                  self.rxbuf.extend(data)

                  while len(self.rxbuf) >= self.packet_len:

                      if self.rxbuf[0] != 0x47:
                          pos = self.rxbuf.find(b"\x47")

                          if pos < 0:
                              self.rxbuf.clear()
                              break

                          del self.rxbuf[:pos]

                      if len(self.rxbuf) < self.packet_len:
                          break

                      pkt = bytes(self.rxbuf[:self.packet_len])
                      del self.rxbuf[:self.packet_len]

                      if pkt[0] == 0x47:
                          self.queue.append(pkt)

                          if len(self.queue) > self.max_queue_packets:
                              self.queue.popleft()
                              self.dropped += 1

          def work(self, input_items, output_items):
              out = output_items[0]

              self._drain_udp()

              n_packets = len(out) // self.packet_len

              if n_packets <= 0:
                  return 0

              produced = 0

              for _ in range(n_packets):

                  if self.queue:
                      pkt = self.queue.popleft()
                      self.sent_video += 1
                  else:
                      pkt = self._make_null_packet()
                      self.sent_null += 1

                  out[produced:produced + self.packet_len] = np.frombuffer(
                      pkt, dtype=np.uint8
                  )

                  produced += self.packet_len

              if self.debug:
                  now = time.monotonic()

                  if now - self.last_print >= 1.0:
                      print(
                          f"[mpegts_udp_pacer_source] queue={len(self.queue):4d} "
                          f"video={self.sent_video:5d} "
                          f"null={self.sent_null:5d} "
                          f"dropped={self.dropped:4d}"
                      )

                      self.sent_video = 0
                      self.sent_null = 0
                      self.dropped = 0
                      self.last_print = now

              return produced
    debug: 'True'
    in_port: '4999'
    max_queue_packets: '500'
    packet_len: '188'
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: '188'
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    bandwidth: 2e6
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: tx_vga
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_repeat_0, '0', digital_gmsk_mod_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_repeat_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_gmsk_mod_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_gmsk_mod_0, '0', blocks_multiply_xx_0, '1']
- [epy_block_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [network_udp_source_0, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
