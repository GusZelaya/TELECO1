options:
  parameters:
    author: popo
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M_qam
  id: variable_qtgui_chooser
  parameters:
    label: Order M-QAM
    labels: '[''8-QAM'', ''16-QAM'', ''32-QAM'', ''64-QAM'', ''128-QAM'', ''256-QAM'']'
    num_opts: '0'
    options: '[8, 16, 32, 64, 128, 256]'
    type: int
    value: '16'
  states: {}
- name: byte_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: Amplitud AWGN
    start: '0.0'
    step: '0.01'
    stop: '0.5'
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_0_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/popo/Escritorio/Task6_pruebas/task6_tcp_rx_imagen_prueba.png
    type: byte
    unbuffered: 'True'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    M_qam: M_qam
    _source_code: |-
      import numpy as np
      from gnuradio import gr


      class blk(gr.basic_block):
          """
          Demodulador rectangular M-QAM.

          Entrada:
              Símbolos complejos recibidos.

          Salida:
              Bytes uint8 reconstruidos.

          Valores admitidos:
              M = 8, 16, 32, 64, 128, 256.
          """

          def __init__(self, M_qam=16):
              gr.basic_block.__init__(
                  self,
                  name="qam_demapper_rect",
                  in_sig=[np.complex64],
                  out_sig=[np.uint8],
              )

              self.bit_buffer = []
              self.set_M_qam(M_qam)
              self._last_M_qam = self.M_qam

          def set_M_qam(self, M_qam):
              M_qam = int(M_qam)

              print(f"[qam_demapper_rect] M_qam recibido = {M_qam}", flush=True)

              if M_qam not in [8, 16, 32, 64, 128, 256]:
                  M_qam = 16

              self.M_qam = M_qam
              self.k = int(np.log2(self.M_qam))

              self.i_bits = (self.k + 1) // 2
              self.q_bits = self.k // 2

              self.i_levels = 1 << self.i_bits
              self.q_levels = 1 << self.q_bits

              self.i_values = np.arange(
                  -(self.i_levels - 1),
                  self.i_levels,
                  2,
                  dtype=np.float32
              )

              self.q_values = np.arange(
                  -(self.q_levels - 1),
                  self.q_levels,
                  2,
                  dtype=np.float32
              )

              avg_power = (
                  (self.i_levels ** 2 - 1) / 3.0 +
                  (self.q_levels ** 2 - 1) / 3.0
              )

              self.norm = np.float32(np.sqrt(avg_power))

              # Al cambiar M se limpia el buffer para no mezclar símbolos viejos.
              self.bit_buffer = []

          def _nearest_index(self, value, levels):
              distances = np.abs(levels - value)
              return int(np.argmin(distances))

          def _index_to_bits(self, idx):
              return [(idx >> i) & 1 for i in range(self.k - 1, -1, -1)]

          def general_work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]

              produced = 0
              consumed = 0

              # Detección de cambio dinámico desde el QT GUI Chooser.
              if int(self.M_qam) != int(self._last_M_qam):
                  self.set_M_qam(self.M_qam)
                  self._last_M_qam = self.M_qam

                  print(
                      f"[qam_demapper_rect] cambio dinámico a M_qam = {self.M_qam}",
                      flush=True
                  )

              # Primero se vacían bytes ya formados en el buffer interno.
              while len(self.bit_buffer) >= 8 and produced < len(out):
                  byte_bits = self.bit_buffer[:8]
                  del self.bit_buffer[:8]

                  value = 0

                  for bit in byte_bits:
                      value = (value << 1) | int(bit)

                  out[produced] = value
                  produced += 1

              # Luego se consumen símbolos nuevos solo si hay espacio
              # para entregar los bytes que se formen.
              while consumed < len(inp) and produced < len(out):
                  bits_after_next_symbol = len(self.bit_buffer) + self.k

                  bytes_after_next_symbol = bits_after_next_symbol // 8
                  remaining_output_space = len(out) - produced

                  if bytes_after_next_symbol > remaining_output_space:
                      break

                  sym = inp[consumed]
                  consumed += 1

                  i_rx = float(np.real(sym) * self.norm)
                  q_rx = float(np.imag(sym) * self.norm)

                  i_idx = self._nearest_index(i_rx, self.i_values)
                  q_idx = self._nearest_index(q_rx, self.q_values)

                  idx = q_idx * self.i_levels + i_idx

                  self.bit_buffer.extend(self._index_to_bits(idx))

                  while len(self.bit_buffer) >= 8 and produced < len(out):
                      byte_bits = self.bit_buffer[:8]
                      del self.bit_buffer[:8]

                      value = 0

                      for bit in byte_bits:
                          value = (value << 1) | int(bit)

                      out[produced] = value
                      produced += 1

              self.consume(0, consumed)

              return produced
  states: {}
- name: network_tcp_source_0
  id: network_tcp_source
  parameters:
    addr: 127.0.0.1
    port: '6000'
    server: 'True'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [epy_block_1, '0', blocks_file_sink_0, '0']
- [network_tcp_source_0, '0', epy_block_1, '0']
- [network_tcp_source_0, '0', qtgui_const_sink_x_1, '0']
- [network_tcp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [network_tcp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
